## firmware/esp32/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=y
CONFIG_LWIP_IP_FORWARD=y
CONFIG_LWIP_NAT=y
CONFIG_USB_HOST_ENABLE=y
```
